## Kconfig
```kconfig
menu "zmk-new_corne"

config ZMK_NEW_CORNE
    bool "ZMK New Corne board support"
    default y

endmenu
```
